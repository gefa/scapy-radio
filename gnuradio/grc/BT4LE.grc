options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: chan_select
  id: variable
  parameters:
    value: '37'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[]'
    num_opts: '0'
    options: '[1000000 * (2402 + 2 * (i)) for i in range(0, 40)]'
    type: raw
    value: '2402000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: gain_rec
  id: variable
  parameters:
    value: '30'
  states: {}
- name: gain_send
  id: variable
  parameters:
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: seuil
  id: variable
  parameters:
    value: '-50'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: seuil
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: bt4le_packet_sink_0_0_0
  id: bt4le_packet_sink
  parameters:
    i_chan_nbr: chan_select
  states: {}
- name: bt4le_preamble_prefixer_0
  id: bt4le_preamble_prefixer
  parameters: {}
  states: {}
- name: bt4le_whitening_0
  id: bt4le_whitening
  parameters:
    chan_nbr: '37'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.030'
    mu: '0.5'
    omega_relative_limit: '0.200'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_1
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: RX/TX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: gain_send
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    clock_source0: external
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_simple_squelch_cc_0, '0', digital_gmsk_demod_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', digital_gmsk_mod_1, '0']
- [blocks_socket_pdu_0, pdus, bt4le_preamble_prefixer_0, in]
- [bt4le_packet_sink_0_0_0, out, blocks_message_debug_0_0, print_pdu]
- [bt4le_packet_sink_0_0_0, out, blocks_socket_pdu_0_0, pdus]
- [bt4le_preamble_prefixer_0, out, bt4le_whitening_0, in]
- [bt4le_whitening_0, out, blocks_message_debug_0, print_pdu]
- [bt4le_whitening_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [digital_gmsk_demod_0, '0', bt4le_packet_sink_0_0_0, '0']
- [digital_gmsk_mod_1, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
